# Keil uVision project pelvic.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pelvic
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F30X_HD = 0.__TARGET_FPU_VFP,DEBUG
  c include: ..\..\..\source\config;..\..\..\source\task;..\..\..\source\mcal\inc;..\..\..\GD32F303CC_StdPeriph_Lib;..\..\..\GD32F303CC_StdPeriph_Lib\Include;..\..\..\source\bsw\systemservice\CMSIS;..\..\..\source\bsw\systemservice\CMSIS\GD\GD32F30x\Include;..\..\..\source\bsw\osservice\FreeRTOS\Source\include;..\..\..\source\bsw\osservice\FreeRTOS\Source\CMSIS_RTOS_V2\inc;..\..\..\source\bsw\osservice\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\source\bsw\osservice\FreeRTOS\Source
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group main
    ../../../source/: main.c
    ../../../source/config/: sys_config.h
  group mcal
    ../../../source/mcal/src/: mcal_gpio.c mcal_dma.c mcal_adc.c mcal_uart.c mcal_timer.c mcal_dac.c mcal_dog.c mcal_flash.c mcal_pwm.c
  group task
    ../../../source/task/: mytask.c mytask.h
  group freertos
    ../../../source/bsw/osservice/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c FreeRTOSConfig.h
    ../../../source/bsw/osservice/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../source/bsw/osservice/FreeRTOS/Source/CMSIS_RTOS_V2/src/: cmsis_os2.c
    ../../../source/bsw/osservice/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group GD32F303CC_StdPeriph_Lib
    ../../../GD32F303CC_StdPeriph_Lib/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
    ../../../source/bsw/systemservice/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group startup
    ../../../source/bsw/systemservice/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
